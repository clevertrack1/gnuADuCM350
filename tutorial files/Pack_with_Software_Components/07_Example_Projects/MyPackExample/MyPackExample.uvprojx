# Keil uVision project MyPackExample.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: LPC1810 NXP
  cpu: IRAM(0x10000000,0x10000) IRAM2(0x20000000,0x4000) CPUTYPE("Cortex-M3") CLOCK(180000000) ELITTLE
  output: MyPackExample
  c flags: Optim=1
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x4000
  group Source Group 1
    ./: main.c
  group ::CMSIS
    C:/Keilv510/ARM/PACK/ARM/CMSIS/3.20.4/CMSIS_RTX/Lib/ARM/: RTX_CM3.lib
    RTE/CMSIS/: RTX_Conf_CM.c
  group ::Device
    RTE/Device/LPC1810/: RTE_Device.h startup_LPC18xx.s system_LPC18xx.c
  group ::MyVariant
    C:/Keilv510/ARM/PACK/MyVendor/MyPack/1.0.3/MySWComp/: mylib_cm3.lib mylib_one.c mylib_two.c
    RTE/MyVariant/: config_mylib.h
software components: CMSIS:CORE 3.20.0, CMSIS:RTOS:Keil RTX 4.74.0, Device:Startup 1.0.0, MyVariant:MyGroup 1.0.2
